# IAR project CenterFinder.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; std
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CenterFinder.srec
  ILINK.IlinkOutputFile: CenterFinder.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: init.h main.c startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group std
    std/: misc.c misc.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h
